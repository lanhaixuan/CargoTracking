# Keil uVision project Cargo Tracking.uvprojx, settings and files
target Cargo Tracking (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Cargo Tracking
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\WORKBOOK\GPS;..\WORKBOOK\KEY;..\WORKBOOK\LED;..\WORKBOOK\MPU6050;..\WORKBOOK\MPU6050\eMPL;..\WORKBOOK\SIM900A;..\WORKBOOK\TIMER2;..\WORKBOOK\TIMER3;..\WORKBOOK\USART2;..\WORKBOOK\USART3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../USER/: main.c stm32f10x_it.c
  group SIM900A
    ../WORKBOOK/SIM900A/: sim900a.c
  group MPU6050
    ../WORKBOOK/MPU6050/: mpu6050.c mpuiic.c
    ../WORKBOOK/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group GPS
    ../WORKBOOK/GPS/: gps.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group WORKBOOK
    ../WORKBOOK/KEY/: key.c
    ../WORKBOOK/LED/: led.c
    ../WORKBOOK/TIMER2/: timer2.c
    ../WORKBOOK/TIMER3/: timer3.c
    ../WORKBOOK/USART2/: usart2.c
    ../WORKBOOK/USART3/: usart3.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
